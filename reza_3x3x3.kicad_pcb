# Repository knielsen/ledcube_3x3x3_labi

## KiCad design reza_3x3x3.kicad_pcb

Parts:
C1: 100n
C2: 1u
CON1: BARREL_JACK
IC1: ATMEGA88PA-P; DIL28
K1, K2: CONN_3
P1, P2: CONN_9
P3: DIL6
P4: CONN_2
R1, R2, R3, R4, R5, R6, R7, R8, R9: 680
U1: LP2950; TO-92

Connections:
+5V: C1.1, C2.1, IC1.7 (VCC), IC1.20 (AVCC), P3.2, U1.1 (OUT)
/led1: IC1.4 ((PCINT18/INT0)PD2), P2.1, R9.2
/led2: IC1.5 ((PCINT19/OC2B/INT1)PD3), P2.2, R8.2
/led3: IC1.6 ((PCINT20/XCK/T0)PD4), P2.3, R7.2
/led4: IC1.11 ((PCINT21/OC0B/T1)PD5), P2.4, R6.2
/led5: IC1.12 ((PCINT22/OC0A/AIN0)PD6), P2.5, R5.2
/led6: IC1.13 ((PCINT23/AIN1)PD7), P2.6, R4.2
/led7: IC1.14 ((PCINT0/CLKO/ICP1)PB0), P2.7, R3.2
/led8: IC1.15 ((PCINT1/OC1A)PB1), P2.8, R2.2
/led9: IC1.16 ((PCINT2/OC1B/SS)PB2), P2.9, R1.2
/reset: IC1.1 ((PCINT14/RESET)PC6), P3.5
/row1: IC1.17 ((PCINT3/OC2A/MOSI)PB3), K1.3, K2.1, P3.4
/row2: IC1.18 ((PCINT4/MISO)PB4), K1.2 (PM), K2.2 (PM), P3.1
/row3: IC1.19 ((PCINT5/SCK)PB5), K1.1, K2.3, P3.3
/ser_rx: IC1.2 ((PCINT16/RXD)PD0), P4.1
/ser_tx: IC1.3 ((PCINT17/TXD)PD1), P4.2 (PM)
GND: C1.2, C2.2, CON1.3, IC1.8 (GND), IC1.22 (GND), P3.6, U1.2 (GND)
unnamed: P1.9, R9.1
unnamed: P1.8, R8.1
unnamed: P1.7, R7.1
unnamed: P1.6, R6.1
unnamed: P1.5, R5.1
unnamed: P1.4, R4.1
unnamed: P1.3, R3.1
unnamed: P1.2, R2.1
unnamed: P1.1, R1.1
unnamed: CON1.1, U1.3 (IN)

Board: 2 copper layers, 50.0 x 50.0 mm, 20 parts (0 on the bottom side), 27 nets.

## Commit log

2013-08-08 First version of Labitat 3x3x3 LED cube mini project, with Arduino shield and on-board AtmegaX8 options.
2014-04-02 v4 manufacture @ seedstudio
